File: bms-kicad-project/PowerTree.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: feat: initial pass at rev. B
Other:
- note added: "45mA MAX"
